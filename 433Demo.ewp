# IAR project 433Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc; ..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\src; ..\xlightCommon-stm8s\Xlight_lib; Project\lib
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../xlightCommon-stm8s/Xlight_lib/: delay.c delay.h Uart2Dev.c Uart2Dev.h
    Project/lib/: drv_CC1101.c drv_CC1101.h drv_CC1101_Reg.h drv_spi.c drv_spi.h
  group src
    Project/src/: main.c
  group STM8S_stdLib
    ../xlightCommon-stm8s/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_spi.c stm8s_uart2.c
    ../xlightCommon-stm8s/STM8S_StdPeriph_Driver/inc/: stm8s_clk.h stm8s_gpio.h stm8s_spi.h stm8s_uart2.h
