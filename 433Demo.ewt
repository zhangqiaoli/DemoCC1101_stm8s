<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>inc</name>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Project\lib\drv_CC1101.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Project\lib\drv_CC1101.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Project\lib\drv_CC1101_Reg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Project\lib\drv_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Project\lib\drv_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\stm8s_it.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\Uart2Dev.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\Uart2Dev.h</name>
    </file>
  </group>
  <group>
    <name>src</name>
    <file>
      <name>$PROJ_DIR$\Project\src\main.c</name>
    </file>
  </group>
  <group>
    <name>STM8S_stdLib</name>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc\stm8s_clk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc\stm8s_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc\stm8s_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc\stm8s_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\src\stm8s_uart2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\xlightCommon-stm8s\STM8S_StdPeriph_Driver\inc\stm8s_uart2.h</name>
    </file>
  </group>
</project>


